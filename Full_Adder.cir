* C:\SPB_Data\eSim-Workspace\Full_Adder\Full_Adder.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 2/1/2022 3:58:50 PM

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
M1  /vdd /vin_a Net-_M1-Pad3_ /vdd mosfet_p
M2  /vdd /vin_a Net-_M2-Pad3_ /vdd mosfet_p
M3  /vdd /vin_b Net-_M2-Pad3_ /vdd mosfet_p
M4  /vdd /vin_c Net-_M4-Pad3_ /vdd mosfet_p
M5  /vdd /vin_a Net-_M4-Pad3_ /vdd mosfet_p
M6  /vdd /vin_b Net-_M4-Pad3_ /vdd mosfet_p
M7  Net-_M1-Pad3_ /vin_b Net-_M14-Pad2_ /vdd mosfet_p
M8  Net-_M2-Pad3_ /vin_c Net-_M14-Pad2_ /vdd mosfet_p
M9  Net-_M4-Pad3_ Net-_M14-Pad2_ Net-_M12-Pad3_ /vdd mosfet_p
M10  /vdd /vin_a Net-_M10-Pad3_ /vdd mosfet_p
M11  Net-_M10-Pad3_ /vin_b Net-_M11-Pad3_ /vdd mosfet_p
M12  Net-_M11-Pad3_ /vin_c Net-_M12-Pad3_ /vdd mosfet_p
M13  /vdd Net-_M12-Pad3_ /sum /vdd mosfet_p
M28  /sum Net-_M12-Pad3_ GND GND mosfet_n
M21  Net-_M14-Pad2_ /vin_b Net-_M15-Pad1_ GND mosfet_n
M15  Net-_M15-Pad1_ /vin_a GND GND mosfet_n
M16  Net-_M16-Pad1_ /vin_a GND GND mosfet_n
M17  Net-_M16-Pad1_ /vin_a GND GND mosfet_n
M18  Net-_M18-Pad1_ /vin_c GND GND mosfet_n
M22  Net-_M14-Pad2_ /vin_c Net-_M16-Pad1_ GND mosfet_n
M19  Net-_M18-Pad1_ /vin_a GND GND mosfet_n
M23  Net-_M12-Pad3_ Net-_M14-Pad2_ Net-_M18-Pad1_ GND mosfet_n
M20  Net-_M18-Pad1_ /vin_b GND GND mosfet_n
M26  Net-_M12-Pad3_ /vin_c Net-_M25-Pad1_ GND mosfet_n
M25  Net-_M25-Pad1_ /vin_b Net-_M24-Pad1_ GND mosfet_n
M24  Net-_M24-Pad1_ /vin_a GND GND mosfet_n
M27  /carry Net-_M14-Pad2_ GND GND mosfet_n
M14  /vdd Net-_M14-Pad2_ /carry /vdd mosfet_p
U1  /vdd /vin_a /vin_b /vin_c /sum /carry PORT

.end
